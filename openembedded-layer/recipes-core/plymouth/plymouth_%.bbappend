PACKAGECONFIG_append_mx6 = " drm"
