PACKAGECONFIG_GL_mx6 = "gles2"

